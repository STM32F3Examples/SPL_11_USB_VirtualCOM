# Keil uVision project SPL_11_USB_VirtualCOM_STM32F3.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F302R8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SPL_11_USB_VirtualCOM_STM32F3
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER  STM32F302x8  USE_STM32303C_EVAL
  c include: ..\include;..\STM32F30x_StdPeriph_Driver\inc;..\STM32_USB-FS-Device_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ../source/: main.c hw_config.c stm32_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group STM32_USB
    ../STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group SPL
    ../STM32F30x_StdPeriph_Driver/: SPL_STM32F302x8.lib
software components: CMSIS:CORE 4.1.0, Device:Startup 1.2.0
